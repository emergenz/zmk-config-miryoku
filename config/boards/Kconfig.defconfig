## config/boards/Kconfig.defconfig
```kconfig
if SHIELD_CALMAR_ONE

config ZMK_KEYBOARD_NAME
    default "calmar-one"
    
endif
```
